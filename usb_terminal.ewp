# IAR project usb_terminal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xF ST STM32F103xF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_XL; STM32F103xG
  ICCARM.CCIncludePath2: app; board; library\inc; module; $PROJ_DIR$; i2c\; shell\; HAL\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_terminal.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: config\conf.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: NDEBUG; EMB_FLASH; STM32F10X_XL; STM32F103xG
  group (top)
    app/: main.c stm32f10x_it.c
  group FLASH
    ./: flash.c flash.h
  group func
    ./: func.c func.h
  group helpTimer
    ./: helpTimer.c helpTimer.h
  group I2C
    i2c/: i2c.c i2c.h
  group LIB/CMSIS
    board/: arm_comm.h
    ./: stm32f10x.h
  group LIB/HAL/src
    HAL/src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c system_stm32f1xx.c
  group LIB/STM32F10xFWLib
    library/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c
  group LIB/Vectors
    app/: stm32f10x_vector.c
  group Other
    app/: includes.h
    ./: write.c
  group PID
    ./: algIncludes.h limitArray.c limitArray.h PID.c PID.h
  group shell
    shell/: ring_buffer.c ring_buffer.h sh_exec.c sh_exec.h shell.c shell.h
  group utils
    i2c/: utils.c utils.h
